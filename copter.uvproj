# Keil uVision project copter.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: copter
  AfterMake: fromelf.exe --bin -o ./bin/copter.bin "#L"
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\config;.\drivers\interface;.\hal\interface;.\modules\interface;.\utils\interface;.\lib\CMSIS\include;.\lib\STM32F4xx_StdPeriph_Driver\inc;.\lib\FreeRTOS\include;.\lib\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group init
    ./init/: main.c
  group config
    ./config/: config.h FreeRTOSConfig.h stm32f4xx_conf.h nvicconf.h
  group drivers
    ./drivers/src/: stm32f4xx_it.c uart_syslink.c led.c i2cdev.c i2croutines.c hmc5883l.c mpu6050.c motors.c encoder.c esp8266.c
  group hal
    ./hal/src/: imu.c ledseq.c uartWiFilnk.c
  group moudles
    ./modules/src/: system.c sensfusion6.c comm.c pid.c controller_balance.c stabilizer_balance.c commander_balance.c data_handling.c
  group utils
    ./utils/src/: eprintf.c filter.c
  group lib/CMSIS
    ./lib/CMSIS/src/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group lib/STM32F4xx_StdPeriph_Driver
    ./lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group lib/freertos/portable
    ./lib/FreeRTOS/portable/MemMang/: heap_2.c
    ./lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group lib/freertos
    ./lib/FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
